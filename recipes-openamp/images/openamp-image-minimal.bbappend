IMAGE_INSTALL_remove += " \
    kernel-module-remoteproc \
    kernel-module-virtio \
    kernel-module-virtio-ring \
"
